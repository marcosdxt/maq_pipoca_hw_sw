# IAR project AirPopCorn.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LPC1768 NXP LPC1768
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: mais_pipoca_1_10_4_UY_60Hz.hex
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkIcfFile: AirPopCorn.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: c.srec
  group (top)
    ./: cstartup_M.asm main.c
  group APLICACAO/ASSINATURA
    Aplicacao/Assinatura/: Assinatura.c
  group APLICACAO/CONTROLE_MOTOR
    Aplicacao/ControleMotor/: ControleEmbalagem.c ControleMotor.c DosadorMilho.c PIDtemperatura.c
  group APLICACAO/HORIMETRO
    Aplicacao/Horimetro/: Horimetro.c
  group APLICACAO/IMPRESSORA
    Aplicacao/Impressora/: Impressora.c
  group APLICACAO/InterfaceUsuario
    Aplicacao/InterfaceUsuario/: AcumuladorDinheiro.c AnimacaoLeds.c ControleAmostraGratis.c InterfacAjusteRelogio.c InterfaceUsuario.c MenuConfiguracaoSistema.c MonitorPagamentos.c PipocaTeste.c
  group APLICACAO/PARAMETROS
    Aplicacao/Parametros/: Parametros.c
  group APLICACAO/RELATORIOVENDAS
    Aplicacao/RelatorioVendas/: RelatorioVendas.c
  group APLICACAO/TELET
    Aplicacao/TELET/: TELET.C
  group board
    target/: board.h
  group DRIVERS/74HC595
    Drivers/74595/: 74595.C
  group DRIVERS/ADC
    Drivers/AmostragemAnalogica/: AmostraAnalogica.c
  group DRIVERS/CCTALK
    Drivers/CCTALK/: cctalk.c
  group DRIVERS/PLAYERWAVE
    Drivers/PlayerWave/: PlayerWave.c
  group DRIVERS/PROTOCOLO
    Drivers/Protocolo/: Protocolo.c Protocolo.txt
  group DRIVERS/RTC
    Drivers/RTC/: RTC.C
  group DRIVERS/SST25VF016
    Drivers/sst25vf016b/: memoryWrapper.c spi_wrapper.c sst25vf016b.c
  group DRIVERS/TECLADO
    Drivers/Teclado/: Teclado.c
  group DRIVERS/UARTS
    Drivers/UARTS/: uart.c
  group DRIVERS/WATCHDOG
    Drivers/WATCHDOG/: WATCHDOG.C
  group DRIVERS/WH1602
    Drivers/WH1602/: WH1602.C
  group DRIVERS/WH1602_2
    Drivers/WH1602_2/: WH1602_2.C
  group RTOS
    Kernel/: heap_1.c list.c port.c portasm.s queue.c tasks.c
  group SENHAS
    ./: senhas.h
  group TARGET
    target/: board.c
